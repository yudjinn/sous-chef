PREFIX ?= "/usr"
PREFIX ?= "/opt/ignored"
