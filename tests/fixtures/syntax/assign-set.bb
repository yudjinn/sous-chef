SUMMARY = "plain set"
EMPTY = ""
SPACED   =   "spaces around the operator"
NOSPACE="no spaces at all"
