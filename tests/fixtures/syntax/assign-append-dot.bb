PATHVAR = "/usr"
PATHVAR .= "/bin"
