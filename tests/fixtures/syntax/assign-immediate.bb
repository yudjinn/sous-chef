BASE = "one"
SNAPSHOT := "${BASE} two"
BASE = "changed"
