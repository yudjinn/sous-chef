SINGLE = 'single quoted with "double" inside'
DOUBLE = "double quoted with 'single' inside"
HASH = "a # inside quotes is not a comment"
