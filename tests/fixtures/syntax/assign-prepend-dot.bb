PATHVAR = "bin"
PATHVAR =. "/usr/"
