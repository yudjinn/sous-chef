FOO = "x"
unset FOO
do_compile[dirs] = "${B}"
unset do_compile[dirs]
