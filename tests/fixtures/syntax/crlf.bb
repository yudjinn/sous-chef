A = "crlf line endings"
B = "continued \
     value"
do_x() {
	echo x
}
