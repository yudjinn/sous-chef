def helper(d):
    value = d.getVar('PN')

    return value + "-helper"

def second(d, x=1):
    return x
AFTER = "after the def block"
