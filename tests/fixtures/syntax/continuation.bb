SRC_URI = "https://example.org/a.tar.gz \
           file://one.patch \
           file://two.patch \
           "
AFTER = "after the continued value"
