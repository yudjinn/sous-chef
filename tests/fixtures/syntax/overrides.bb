VAR = "base"
VAR:append = " appended"
VAR:prepend = "prepended "
VAR:remove = "base"
VAR:qemux86 = "machine value"
VAR:append:qemux86 = " machine append"
VAR:qemux86:append = " append to the variant"
VAR:qemux86 += "parse-time append to the variant"
VAR:pn-hello:class-target = "chained overrides"
FILES:${PN}-dev:append = " ${libdir}/cmake"
