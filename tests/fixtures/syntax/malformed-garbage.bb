GOOD = "before"
this is not bitbake at all
= "missing name"
VAR = "unterminated quote
}
AFTER = "the parser recovers"
