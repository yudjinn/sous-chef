GOOD = "before"
do_broken() {
	echo "this body never closes"
	  }
NOT_A_STATEMENT = "swallowed by the body"
