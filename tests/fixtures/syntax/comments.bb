# A comment line.
#No space after the hash.
   # Indented comment.
VAR = "value"

# Comment before a blank line.

OTHER = "value"
