GREETING ??= "hello"
GREETING ??= "hi"
