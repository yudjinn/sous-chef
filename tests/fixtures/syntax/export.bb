export CC = "gcc"
export PKG_CONFIG_PATH
export   SPACED_EXPORT ?= "x"
