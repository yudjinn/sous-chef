require dup.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=11111111111111111111111111111111"
SRC_URI[sha256sum] = "1111111111111111111111111111111111111111111111111111111111111111"
