require dup.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=22222222222222222222222222222222"
SRC_URI[sha256sum] = "2222222222222222222222222222222222222222222222222222222222222222"
DEPENDS += "openssl"
