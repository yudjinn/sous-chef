SRC_URI += "file://local.patch"

SRC_URI:append = " file://from-recipe.cfg"
