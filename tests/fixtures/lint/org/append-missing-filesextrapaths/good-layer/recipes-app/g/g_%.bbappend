require g-extra.inc
SRC_URI += "file://g.patch"
