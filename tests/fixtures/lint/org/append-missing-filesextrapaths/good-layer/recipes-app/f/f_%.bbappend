FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://local.patch"
