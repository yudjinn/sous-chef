# lint-precision: trimmed from OE-core (wrynose) recipes-devtools/clang/clang_git.bb.
SUMMARY = "LLVM based C/C++ compiler"
LICENSE = "Apache-2.0-with-LLVM-exception"

require common-clang.inc
