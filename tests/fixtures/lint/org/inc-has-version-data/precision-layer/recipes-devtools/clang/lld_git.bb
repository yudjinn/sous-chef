# lint-precision: trimmed from OE-core (wrynose) recipes-devtools/clang/lld_git.bb.
SUMMARY = "LLVM Linker"
LICENSE = "Apache-2.0-with-LLVM-exception"

require common-clang.inc
