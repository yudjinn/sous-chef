# lint-precision: trimmed from OE-core (wrynose) recipes-devtools/clang/llvm-project-source.bb
# (no version in the file name).
SUMMARY = "This is the LLVM project source tree"
LICENSE = "Apache-2.0-with-LLVM-exception"

require common-clang.inc
