BADCLASS ?= "1"
