CORETHING ?= "1"
