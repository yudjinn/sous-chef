EXTRA_OECONF += "--g"
