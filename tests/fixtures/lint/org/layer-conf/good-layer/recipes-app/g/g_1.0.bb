SUMMARY = "x"
LICENSE = "MIT"
inherit corething
