GOODCLASS ?= "1"
