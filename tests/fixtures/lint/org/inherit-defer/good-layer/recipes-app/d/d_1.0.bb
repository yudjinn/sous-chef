DCLASS = "classa"
inherit_defer ${DCLASS}
DCLASS = "classb"
