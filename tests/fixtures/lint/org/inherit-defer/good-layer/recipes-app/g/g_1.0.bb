GCLASS = "classa"
inherit ${GCLASS}
OTHER = "x"
