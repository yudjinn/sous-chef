DCLASS = "classa"
inherit ${DCLASS}
DCLASS = "classb"
