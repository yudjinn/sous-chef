inherit ${@d.getVar("ECLASS")}
