inherit foo ${FCLASS}

python () {
    d.setVar("FCLASS", "classa")
}
