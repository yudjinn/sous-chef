FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://fix.patch"
SRCREV = "0123456789abcdef0123456789abcdef01234567"
