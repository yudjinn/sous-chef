SUMMARY = "x"
LICENSE = "MIT"
inherit core-image
IMAGE_INSTALL += "p"
