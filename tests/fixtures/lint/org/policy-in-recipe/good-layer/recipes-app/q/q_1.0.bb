SUMMARY = "x"
LICENSE = "MIT"
inherit ${QCLASS}
IMAGE_INSTALL += "q"
