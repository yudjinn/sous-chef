require u.inc
LICENSE = "MIT"
include conf/distro/include/${MY_DISTRO_NAME}-extra.inc
