SUMMARY = "x"
LICENSE = "MIT"

inherit image
