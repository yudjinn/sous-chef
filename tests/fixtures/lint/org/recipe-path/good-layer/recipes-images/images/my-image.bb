SUMMARY = "x"
LICENSE = "MIT"

inherit core-image
