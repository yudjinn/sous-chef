SUMMARY = "x"
LICENSE = "MIT"

inherit packagegroup
