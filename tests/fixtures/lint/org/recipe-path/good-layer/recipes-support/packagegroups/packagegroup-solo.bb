# Alone in packagegroups/, as OE-core keeps them (recipes-*/packagegroups/).
SUMMARY = "x"
LICENSE = "MIT"

inherit packagegroup
