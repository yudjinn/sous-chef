# Still reported: nothing here sets PV (only an override of it).
SUMMARY = "x"
LICENSE = "MIT"
PV:class-native = "2.0"
