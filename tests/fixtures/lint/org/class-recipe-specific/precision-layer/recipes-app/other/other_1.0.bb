# Still reported: a value of its own that the class replaces.
SUMMARY = "Other"
LICENSE = "MIT"
S = "${WORKDIR}/other-src"

inherit pypiish
