FETCHY_MODE = "slow"
inherit fetchy
FETCHY_OTHER = "y"
