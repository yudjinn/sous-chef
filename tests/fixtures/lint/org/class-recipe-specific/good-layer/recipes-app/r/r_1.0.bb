FETCHY_MODE = "slow"
inherit fetchy
FETCHY_INTERNAL = "y"
