BOTH ?= "1"
