SUMMARY = "x"
LICENSE = "MIT"
inherit a both
