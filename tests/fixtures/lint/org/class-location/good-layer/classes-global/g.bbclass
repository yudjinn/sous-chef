G ?= "1"
