MYRECIPECLASS ?= "1"
