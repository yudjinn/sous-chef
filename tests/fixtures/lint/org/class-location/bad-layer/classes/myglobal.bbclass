MYGLOBAL ?= "1"
