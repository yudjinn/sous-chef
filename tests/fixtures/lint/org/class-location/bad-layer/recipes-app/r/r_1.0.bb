SUMMARY = "x"
LICENSE = "MIT"
inherit myrecipeclass
