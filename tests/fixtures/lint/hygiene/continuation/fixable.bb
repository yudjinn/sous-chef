SUMMARY = "Whitespace after trailing backslashes"
DEPENDS = "zlib \   
    openssl \	
    bzip2"
