SUMMARY = "Continuation problems"
DEPENDS = "zlib \   
    openssl"
RDEPENDS:${PN} = "bash \

EXTRA_OECONF = "--disable-x"
