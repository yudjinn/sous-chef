SUMMARY = "SRCPV in PV, renamed variables"
LICENSE = "MIT"
PV = "1.0+git"
PV:append:x = ""
SKIP_RECIPE[foo] = "broken"
LICENSE_FLAGS_ACCEPTED:append = " commercial"
export BB_ENV_PASSTHROUGH_ADDITIONS = "FOO"
WHITELIST_GPL-3.0-only = "x"
