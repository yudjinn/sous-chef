SUMMARY = "SRCPV in PV"
LICENSE = "MIT"
PV = "1.0+git${SRCPV}"
PV:append:x = "${SRCPV}"
