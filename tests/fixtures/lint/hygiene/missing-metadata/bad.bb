DESCRIPTION = "A recipe without a summary, license or license checksums."
SRC_URI = "https://example.org/releases/bad-${PV}.tar.gz"
SRC_URI[sha256sum] = "1111111111111111111111111111111111111111111111111111111111111111"
