# No SRC_URI at all: no upstream (no HOMEPAGE asked), no LIC_FILES_CHKSUM needed, but
# SUMMARY and LICENSE still are.
DESCRIPTION = "A recipe that fetches nothing"
