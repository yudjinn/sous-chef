SUMMARY = "Closed source: no license checksums needed"
HOMEPAGE = "https://example.org/closed"
LICENSE = "CLOSED"
SRC_URI = "file://main.c"
