BROKEN_CLASS = "1"
this line is not bitbake
