SUMMARY = "A recipe with an unparsed line"
LICENSE = "MIT"
require broken.inc
inherit broken
this line is not bitbake
