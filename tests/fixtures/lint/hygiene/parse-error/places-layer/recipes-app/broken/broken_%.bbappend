EXTRA = "1"
this line is not bitbake
