SUMMARY = "Requires an .inc by a python expression"
LICENSE = "MIT"
require ${@'dyn-extra.inc'}
