SUMMARY = "Parsed wherever the collection absent is present"
LICENSE = "MIT"
this line is not bitbake
