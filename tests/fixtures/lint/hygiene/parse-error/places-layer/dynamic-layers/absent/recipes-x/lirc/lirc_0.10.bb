SUMMARY = "Collected only with the layer of collection absent"
LICENSE = "MIT"
SRC_URI = "file://lircd.conf file://defaults.conf file://old.conf"
