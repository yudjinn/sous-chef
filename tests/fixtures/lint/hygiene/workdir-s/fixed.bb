SUMMARY = "Sources directly in WORKDIR"
SRC_URI = "file://main.c"
S = "${UNPACKDIR}"

S:class-native = "${UNPACKDIR}"
