SUMMARY = "Sources directly in WORKDIR"
SRC_URI = "file://main.c"
S = "${WORKDIR}"

S:class-native = "${WORKDIR}/"
