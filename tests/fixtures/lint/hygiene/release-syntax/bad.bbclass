# Linted as classes-recipe/bad.bbclass: a directory Kirkstone never searches.
EXTRA_OECONF += "--enable-bad"
