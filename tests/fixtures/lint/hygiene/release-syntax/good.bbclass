# Linted as classes/good.bbclass: searched on every release.
EXTRA_OECONF += "--enable-good"
