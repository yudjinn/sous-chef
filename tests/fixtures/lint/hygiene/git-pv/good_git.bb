SUMMARY = "A git recipe that sets PV"
LICENSE = "MIT"
SRC_URI = "git://example.org/x.git;protocol=https;branch=main"
SRCREV = "0123456789abcdef0123456789abcdef01234567"
PV = "1.2+git"
