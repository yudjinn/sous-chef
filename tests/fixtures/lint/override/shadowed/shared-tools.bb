# The other includer of shared.inc, which keeps its values.
SUMMARY = "U-Boot tools"
require shared.inc
