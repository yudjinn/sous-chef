SUMMARY = "Assignments that are always overwritten"
LICENSE = "MIT"
require bad.inc

MY_FLAGS = "-O1"
MY_FLAGS += "-g"
MY_FLAGS = "-O2"
SECTION = "base"
