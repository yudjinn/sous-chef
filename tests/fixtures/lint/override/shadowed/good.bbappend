# Replacing the recipe's value is what a bbappend is for.
HOMEPAGE = "https://example.org/b"
