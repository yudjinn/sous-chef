# A class that does not empty PACKAGES, or empties it and fills it again.
RDEPENDS += "bash"
PACKAGES = ""
PACKAGES += "${PN}-extra"
RDEPENDS = ""
RDEPENDS += ""
