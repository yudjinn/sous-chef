# A recipe with packages.
SUMMARY = "x"
require shared.inc
