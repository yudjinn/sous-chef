# No packages, set directly.
PACKAGES = ""
ALLOW_EMPTY = "1"
require shared.inc
