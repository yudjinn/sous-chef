# A packagegroup has PACKAGES = "${PN}": checked.
inherit packagegroup
RDEPENDS = "bash"
