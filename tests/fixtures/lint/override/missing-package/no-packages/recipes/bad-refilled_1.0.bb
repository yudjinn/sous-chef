# An image that fills PACKAGES again: checked.
inherit core-image
PACKAGES = "${PN}"
RDEPENDS = "bash"
