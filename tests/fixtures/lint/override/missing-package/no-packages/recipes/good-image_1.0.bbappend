# Appends to an image recipe.
RRECOMMENDS:append = " foo"
