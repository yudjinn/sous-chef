# Stand-in for OE-core image.bbclass: an image recipe has no packages.
PACKAGES = ""
