# Stand-in for OE-core core-image.bbclass.
inherit image
