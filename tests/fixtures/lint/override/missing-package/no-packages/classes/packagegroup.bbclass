# Stand-in for OE-core packagegroup.bbclass: one package, the group itself.
PACKAGES = "${PN}"
