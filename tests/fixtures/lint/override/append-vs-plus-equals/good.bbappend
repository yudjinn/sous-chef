# In a bbappend :append is usually right.
DEPENDS = "zlib"
DEPENDS:append = " openssl"
