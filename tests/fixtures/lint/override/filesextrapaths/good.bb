# In the .bb itself a late ${THISDIR} is still the recipe's directory.
FILESEXTRAPATHS:prepend = "${THISDIR}/files:"
