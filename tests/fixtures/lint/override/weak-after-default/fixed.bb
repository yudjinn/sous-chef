# ??= after the variable already has a value in the same file.
MY_A = "x"
MY_B ?= "x"
MY_C[doc] = "d"
MY_D:qemux86 := "x"
