# In a bbappend :remove is acceptable: info only.
PACKAGECONFIG:remove = "x11"
