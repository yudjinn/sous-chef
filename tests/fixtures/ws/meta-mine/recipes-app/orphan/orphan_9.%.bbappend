# Matches no recipe: there is no orphan recipe in the workspace.
SUMMARY:append = " (patched)"
